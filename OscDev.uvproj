# Keil uVision project OscDev.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: OscDev +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.cpp complex.cpp complex.h DefaultFonts.h FFT.cpp FFT.h delay.cpp delay.h pin.cpp pin.h spi1.c ILI9225.cpp pll.cpp pll.h defines.h oscilloscope.cpp fft_fix.cpp
